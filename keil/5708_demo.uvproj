# Keil uVision project 5708_demo.uvproj, settings and files
target 5708demo (MCS-51)
  device: SN8F5708 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FF5) CLOCK(32000000) MODC2 DPC MDU_R515
  output: key_demo +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source;.\Source;.\Source\Buzzer;.\Source\CHRG;.\Source\KEY;.\Source\Timer;.\Source\IIC;.\Source\USER;.\Source\SYS;.\Source\UART;.\Source\LCD;.\Source\LED;.\Source\INC;.\Source\InfraRed;.\Source\ISP;.\Source\WS2811;.\Source\RF;.\Hardware\SN8F5702_Hardware\inc;.\Source\AHT10
  group start
    ./: STARTUP.A51 OPTIONS_SN8F5708.A51
  group user
    ./Source/: main.c timer0.c 7segment_led.c key.c led.c pwm.c i2c.c
  group readme
    ./: readme.txt
